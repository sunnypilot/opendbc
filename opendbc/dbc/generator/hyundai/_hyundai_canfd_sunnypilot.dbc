BO_ 600 ADAS_DRV_INTERCEPT: 8 SP